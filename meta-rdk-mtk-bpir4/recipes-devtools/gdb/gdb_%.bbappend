
LICENSE = "CLOSED"

PACKAGECONFIG_remove_pn-gdb = "readline"
